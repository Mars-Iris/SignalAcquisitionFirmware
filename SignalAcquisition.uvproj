# Keil uVision project SignalAcquisition.uvproj, settings and files
target mainboard (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 贵州省黔南州长顺驾校科目二训练车 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Driver
    ./Source/: gpio.c flash.c usart.c timer.c
  group Bsp
    ./Bsp/: bsp.c bsp_gpio.c bsp_usart.c bsp_flash.c bsp_mcu_id.c bsp_delay.c
  group App
    ./App/: Signal.c Serial.c check.c gps.c
  group User
    ./User/: main.c
